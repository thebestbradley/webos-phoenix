# Fixture: no LICENSE, a download without a checksum, a GPL-3.0 recipe licence elsewhere.
SUMMARY = "Fixture download"
SRC_URI = "https://example.org/thing-${PV}.tar.gz"
