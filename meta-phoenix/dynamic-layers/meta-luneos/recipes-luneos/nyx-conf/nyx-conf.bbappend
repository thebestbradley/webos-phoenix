# webOS Phoenix VMs: gpsConfig.conf names the virtio serial port the host
# feeds NMEA into (nyx-conf/phoenix-vm-arm64/gpsConfig.conf).
FILESEXTRAPATHS:prepend := "${THISDIR}/nyx-conf:"
