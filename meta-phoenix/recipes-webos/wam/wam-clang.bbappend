# Copyright (c) 2026 webOS Phoenix contributors
# SPDX-License-Identifier: Apache-2.0
#
# The user agent Phoenix sets (phoenix-wam.inc). (Named for the recipe as
# OSE and LuneOS have it, unversioned: wam-clang.bb.)

require phoenix-wam.inc
